# Keil uVision project psvstm32cd.uvprojx, settings and files
target psvstm32cd (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: psvstm32cd +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/mbedTLS/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c sdio_hal_ex.c bigmac.c kirk.c cmd56.c gpio.c sdio.c sys_clk.c error_handler.c
    ../Inc/: stm32f4xx_hal_conf.h stm32f4xx_it.h main.h usb_device.h usbd_conf.h usbd_desc.h usbd_storage_if.h sdio_hal_ex.h bigmac.h kirk.h cmd56.h gpio.h sdio.h sys_clk.h error_handler.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_mmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/mbedTLS
    ../Middlewares/Third_Party/mbedTLS/include/mbedtls/: aes.h check_config.h cipher.h cipher_internal.h cmac.h config.h platform.h platform_time.h platform_util.h sha1.h sha256.h threading.h
    ../Middlewares/Third_Party/mbedTLS/src/: aes.c cipher.c cipher_wrap.c cmac.c platform.c platform_util.c sha1.c sha256.c threading.c
software components: CMSIS:CORE 4.3.0
